<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app_bod.ewp</path>
  </project>
  <batchBuild/>
</workspace>
