<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ble_app_uart_periph_s.ewp</path>
  </project>
  <batchBuild/>
</workspace>
