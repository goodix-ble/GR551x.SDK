<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ble_app_uart_at.ewp</path>
  </project>
  <batchBuild/>
</workspace>
